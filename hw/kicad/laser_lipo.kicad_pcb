# Repository noahp/laser_lipo

File README.md:

laser_lipo
==========

Simple board to integrate a laser power supply and a lipo battery charger.

Parts
=====
switch
-----
http://www.mouser.com/ProductDetail/ALPS/SSSS810701/?qs=sGAEpiMZZMtHXLepoqNyVe%252bcQMRoBF1BAzyvwoNmgBo%3d  

usb
-----
http://www.mouser.com/ProductDetail/Hirose-Connector/UX60SC-MB-5ST01/?qs=sGAEpiMZZMulM8LPOQ%252bykzmHhzPuOAFG8p6j3l8GLq0%3d  

PCB Renders
=====
oshpark visualizations of v0.0

## KiCad design hw/kicad/laser_lipo.kicad_pcb

Parts:
C1, C2: 4.7uF
D1: LED
J1: USB-MINI-B
P1: BAT+
P2: BAT-
P3: LZR+
P4: LZR-
R1: 470R
R2, R3: 2k
SW1: SWITCH_INV
U1: MCP73831
U2: LP3985

Connections:
GND: C1.2, C2.2, J1.5, J1.6, P2.1, P4.1, R2.2, R3.2, U1.2 (vss), U2.2 (GND); also elsewhere on the board
unnamed: R3.1, SW1.1
unnamed 2: P3.1, U2.5 (VOUT); also elsewhere on the board
unnamed: SW1.2, U2.3 (VEN)
unnamed: R2.1, U1.5 (prog)
unnamed: D1.2 (K), R1.1
unnamed: R1.2, U1.1 (stat)
USB_VBUS: C1.1, D1.1 (A), J1.1, U1.4 (vdd)
VBAT+: C2.1, P1.1, SW1.3, U1.3 (vbat), U2.1 (VIN)

Board: 2 copper layers, 27.7 x 14.4 mm, 15 parts (0 on the bottom side), 9 nets.

Other parts of the board:
C3: 1uF; SM0603

Their connections:
GND: C3.2; also elsewhere on the board
unnamed 2: C3.1; also elsewhere on the board

## Commit log

2013-05-14 - add submodule for comp. lib - add kicad project and scematic->done
2013-05-14 - update readme with switch part - add .net file
2013-05-14 - add footprint for slide switch
2013-05-14 - put footprints on pcb
2013-05-19 - finish pcb - add drill and gerbers, need to check them
2013-05-19 - need to run drc for filled zones to populate
2013-05-19 - add output archive - tidy up a bit
2013-05-19 - add pdf of schematic
2013-05-29 - v0.1 - add 1uF cap to output of 3.3v reg
2013-05-30 - need to connect 3.3v regulator to gnd >_<
2013-05-31 - add oshpark renders
